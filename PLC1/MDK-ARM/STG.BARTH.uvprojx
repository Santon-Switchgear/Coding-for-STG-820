# Keil uVision project STG.BARTH.uvprojx, settings and files
target BARTH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F091CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: out
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MICROLIB STM32F091xC USE_HAL_DRIVER
  c misc: --C99
  c include: ../CANopenNode-master;../CANopenNode-master/example;../CANopenNode-master/stack;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Inc
  asm define: STM32F091xC USE_HAL_DRIVER
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ./out.BARTH.sct
  link misc: --diag_suppress=L6329 --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c main_hal.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_uart.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group CANOpen
    ../CANopenNode-master/stack/: CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_trace.c crc16-ccitt.c CO_driver.c
    ../CANopenNode-master/: CANopen.c
    ../CANopenNode-master/example/: CO_OD.c
software components: CMSIS:CORE 5.5.0
