# Keil uVision project STG.uvprojx, settings and files
target BARTH (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F091CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STG
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c main_hal.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_uart.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group CANOpen
    ../CANopenNode-master/stack/: CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_trace.c crc16-ccitt.c CO_driver.c
    ../CANopenNode-master/: CANopen.c
    ../CANopenNode-master/example/: CO_OD.c
    C:/Keil_v5/ARM/ARMCLANG/include/: stdbool.h stdint.h stdio.h
software components: CMSIS:CORE 5.5.0
