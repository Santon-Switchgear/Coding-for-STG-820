# Keil uVision project STG.uvprojx, settings and files
target BARTH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F091CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c main_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_can.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal_dac.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_irda.c stm32f0xx_hal_rcc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c
software components: CMSIS Driver:CAN:Custom 1.0.0, CMSIS:CORE 5.5.0, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:STM32Cube HAL 1.11.0, CMSIS Driver:CAN 1.3.0
